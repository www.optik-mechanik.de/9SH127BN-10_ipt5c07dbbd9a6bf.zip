# Autodesk Inventor part: 9SH127BN-10
## iProperties
Created: 2007-09
Part Number: 9SH127BN-10
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
